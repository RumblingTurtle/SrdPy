Commit message: Last Commit

File: examples/atlas/atlas_v5.urdf (robot description, URDF)
Before this commit: robot drc_skeleton, 36 links, 35 joints
Links:
- added link base
Joints:
- added joint base_to_0: type fixed, parent base, child pelvis, origin xyz=0 0 0 rpy=0 0 0
